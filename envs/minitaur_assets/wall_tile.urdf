Commit message: up urdf

File: envs/minitaur_assets/wall_tile.urdf (robot description, URDF)
Before this commit: robot wall, 1 links, 0 joints
Links:
- link wall_link: mass 10 -> 100
